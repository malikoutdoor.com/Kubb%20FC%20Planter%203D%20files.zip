Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0, QuantityTakeOffAddOnView]
File name: 0001
Time: 2023-10-31T16:33:24
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20180423_1000(x64) - Exporter 18.3.1.2 - Alternate UI 18.3.1.2
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Oct 31 16:33:24 2023 * Host: LAPTOP-RP8DN0OA * Database: C:\Users\claud\AppData\Local\Temp\{6E5652A6-1FD9-4375-9BC1-8504FDD5C30B}\ifc * Database version: 5507 * Database creation date: Tue Oct 31 16:33:23 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Oct 31 16:33:24 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Oct 31 16:33:24 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Nome; Phase: Stato

# IfcSite, Default
RefLatitude: 41, 47, 59, 997253; RefLongitude: 12, 36, 0, 1373; RefElevation: 0 m
Altro - Categoria: Informazioni sul progetto; Data di consegna del progetto: Data; Nome del cliente: Proprietario; Nome del progetto: Nome; Numero del progetto: 0001; Stato del progetto: Stato

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Altro - Categoria: Informazioni sul progetto; Data di consegna del progetto: Data; Nome del cliente: Proprietario; Nome del progetto: Nome; Numero del progetto: 0001; Stato del progetto: Stato

# IfcBuildingStorey, 0 - Piano Terra
LongName: 0 - Piano Terra; Elevation: 0 m
Vincoli(Type) - Base quota altimetrica: Punto base progetto
Grafica(Type) - Colore: 0; Modello di linea: Tratto; Simbolo: Estremità Livello: Triangolo; Simbolo a estremità 1 per default: no; Simbolo a estremità 2 per default: yes; Spessore di linea: 1
Altro - Categoria: Livelli; Famiglia: Livello: Livello; Famiglia e tipo: Livello: Livello; ID tipo: Livello: Livello; Tipo: Livello: Livello
Dati identità - Nome: 0 - Piano Terra; Piano edificio: yes; Strutturale: no
Dimensioni - Altezza di calcolo: 0 m
Vincoli - Quota altimetrica: 0 m
Altro(Type) - Categoria: Livelli; Nome famiglia: Livello
Dati identità(Type) - Nome del tipo: Livello

# IfcBuildingElementProxy: 0FIAR011 - GRANITO - 286 Lt, Fioriera KUBB FC:0FIAR011 - GRANITO - 286 Lt:141410
In: 0 - Piano Terra
Type - Material: GRANITO
Type - Altro - Categoria: Modelli generici; Nome famiglia: Fioriera KUBB FC
Type - Dati identità - BIM Name: KUBB FC - 286 L; BIM Object Type: FIORIERE - PLANTERS; Code: 0FIAR011; Designer: BELLITALIA DESIGN; Family Name: KUBB; Nome del tipo: 0FIAR011 - GRANITO - 286 Lt; URL Eng: https://www.bellitalia.net/en/products/planters/kubb-planters/; URL Ita: https://www.bellitalia.net/prodotti/fioriere/kubb-planters/
Type - Dimensioni - Dimensions: 1806 mm X 768 mm X 440 mm X R 2650 mm X r 2000 mm
Type - Generale - Descrizione Tecnica Famiglia: Fioriera curva a sezione rettangolare modulare mod. “KUBB FC”, costituita da una fioriera monolitica dotata di un dispositivo di riserva d’acqua integrato che garantisce un giusto grado di umidità del terreno evitando che tutta l’acqua immessa all’interno si disperda.; Descrizione Tecnica per Codice: FIORIERA KUBB FC IN GRANITO (COLORE A SCELTA) SABBIATO CON CERCHI SUPERIORI SPAZZOLATI VERNICE ANTIDECADIMENTO; Fissaggio: Appoggio; Fixings: Freestanding; Technical Description Family: Curved planter with modular rectangular section mod. “KUBB FC”, consisting of a monolithic planter equipped of an integrated water reserve device which guarantees the right level of humidity in the soil avoiding that all the water introduced inside is scatter.; Technical Description for Article: KUBB FC PLANTER IN GRANITO (COLOR TO BE CHOSEN) SANDBLASTED WITH BRUSHED UPPER RIMS ANTI-DECAY VARNISH
Type - Materiali e finiture - MATERIALE FIORIERA: GRANITO; Materiale Principale: Granito Bianco; Materiale Secondario: Granito; Primary Material: Reconstituted White Granite; Secondary Material: Reconstituted Granite
Type - Meccanica - Weight ( kg): 510 Kg
Pset_BuildingElementProxyCommon - Reference: 0FIAR011 - GRANITO - 286 Lt
Altro - Famiglia: Fioriera KUBB FC: 0FIAR011 - GRANITO - 286 Lt; Famiglia e tipo: Fioriera KUBB FC: 0FIAR011 - GRANITO - 286 Lt; ID tipo: Fioriera KUBB FC: 0FIAR011 - GRANITO - 286 Lt; Tipo: Fioriera KUBB FC: 0FIAR011 - GRANITO - 286 Lt
Dimensioni - Area: 2.57578 m2; Volume: 0.208188 m3
Fasi - Fase di creazione: Stato di Progetto
Vincoli - Host: Livello : 0 - Piano Terra; Livello: Livello: 0 - Piano Terra; Offset: 0 m; Sposta con l'oggetto più vicino: no
